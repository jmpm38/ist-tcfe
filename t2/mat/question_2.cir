R1 1 2 1.048998e+03
R2 3 2 2.055568e+03
R3 2 5 3.060188e+03
R4 5 0 4.168980e+03
R5 5 6 3.073950e+03
R6 0 7 2.042810e+03
R7 9 8 1.037563e+03
Vs 1 0 0
Vx 6 8 8.563007e+00
Gb 6 3 (2,5) 7.338555e-03
Vaux 7 9 0
Hd 5 8 Vaux 8.258180e+03
